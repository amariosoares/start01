# Keil uVision project start01.uvproj, settings and files
target start01 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: start01 +hex
  c flags: Optim=3
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\Mcu\Libraries\CMSIS\Core\CM3;..\Mcu\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Mcu;..\Mcu\CortexM3;..\uCOS;..\SDK;..\SDK\BSP;..\Bsp\Inc;..\App\Inc;..\Core\inc;..\network\STM32_ETH_Driver\inc;..\network\lwip_v1.3.1\port\STM32;..\network\lwip_v1.3.1\src\include;..\network\lwip_v1.3.1\src\include\ipv4;..\network\inc;..\network\lwip_v1.3.1\src\netif;..\network\lwip_v1.3.1\src\include\lwip;..\anybus\std_driver\ABCC\INCLUDE;..\anybus\std_driver\APDR\INCLUDE;..\anybus\std_driver\SYS\INCLUDE;..\anybus\std_driver\APLINK\INCLUDE;..\anybus\std_driver\UTIL\INCLUDE;..\anybus\std_driver\CRC\INCLUDE;..\anybus\std_driver\APP\INCLUDE;..\anybus\std_driver\APPD\INCLUDE;..\anybus\std_driver\APPC\INCLUDE;..\anybus\std_driver\DPV1\INCLUDE;..\anybus\std_driver\DEV\INCLUDE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\ByOS.sct
  group Bsp_Inc
    ../Bsp/Inc/: bsp.h includes.h ioport.h nvic_init.h static_init.h Power_init.h Key_init.h cs5532_init.h at45db321d_init.h tim2_init.h tim3_init.h tim6_init.h printf_init.h usart1_init.h usart2_init.h usart3_init.h uart4_init.h uart5_init.h Beep_init.h
  group App_Inc
    ../App/Inc/: main.h Command.h ADDispose.h weight.h RS232_DebugComm.h Protocal.h DebugComm.h
  group Core_Inc
    ../Core/inc/: clock.h div64.h
  group app
    ../App/Src/: testsuite.c
    ../obj/: start01.lib
