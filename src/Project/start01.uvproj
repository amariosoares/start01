# Keil uVision project start01.uvproj, settings and files
target start01 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: start01 +hex
  c flags: Optim=3
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\Mcu\Libraries\CMSIS\Core\CM3;..\Mcu\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Mcu;..\Mcu\CortexM3;..\uCOS;..\SDK;..\SDK\BSP;..\Bsp\Inc;..\App\Inc;..\Core\inc;..\network\STM32_ETH_Driver\inc;..\network\lwip_v1.3.1\port\STM32;..\network\lwip_v1.3.1\src\include;..\network\lwip_v1.3.1\src\include\ipv4;..\network\inc;..\network\lwip_v1.3.1\src\netif;..\network\lwip_v1.3.1\src\include\lwip;..\anybus\std_driver\ABCC\INCLUDE;..\anybus\std_driver\APDR\INCLUDE;..\anybus\std_driver\SYS\INCLUDE;..\anybus\std_driver\APLINK\INCLUDE;..\anybus\std_driver\UTIL\INCLUDE;..\anybus\std_driver\CRC\INCLUDE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\ByOS.sct
  group Mcu
    ../Mcu/Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../Mcu/: stm32f10x_it.c stm32f10x_conf.h
    ../Mcu/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_crc.c stm32f10x_pwr.c
    ../Mcu/Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group Bsp_Inc
    ../Bsp/Inc/: bsp.h includes.h ioport.h nvic_init.h static_init.h Power_init.h Key_init.h cs5532_init.h at45db321d_init.h tim2_init.h tim3_init.h tim6_init.h printf_init.h usart1_init.h usart2_init.h usart3_init.h uart4_init.h uart5_init.h Beep_init.h
  group Bsp_Src
    ../Bsp/Src/: nvic_init.c tim2_init.c printf_init.c serial.c timer.c led.c stm32led.c gpio.c stm32usart.c watchdog.c static_init.c bsp.c fm25l16.c rtc_stm32.c stm32_bpk.c
  group App_Inc
    ../App/Inc/: main.h Command.h ADDispose.h weight.h RS232_DebugComm.h Protocal.h DebugComm.h
  group App_Src
    ../App/Src/: main.c DebugComm.c Startup.c ParamCfg.c utils.c datetime.c testsuite.c
  group Core_Src
    ../Core/src/: clock.c div64.c clocksource.c kfifo.c error.c dlmem.c
  group Core_Inc
    ../Core/inc/: clock.h div64.h
  group Net_Src
    ../network/src/: stm32f107.c network.c netconf.c httpserver.c
    ../network/STM32_ETH_Driver/src/: stm32_eth.c
  group Lwip
    ../network/lwip_v1.3.1/port/STM32/: ethernetif.c
    ../network/lwip_v1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../network/lwip_v1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../network/lwip_v1.3.1/src/core/: init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c mem.c
    ../network/lwip_v1.3.1/src/netif/: etharp.c
  group anybus
    ../anybus/std_driver/ABCC/: abcc_cbf.c
    ../anybus/std_driver/APDR/: apdr.c apdr_par.c apdr_ser.c
    ../anybus/std_driver/APLINK/: aplink.c
    ../anybus/std_driver/CRC/: crc.c
    ../anybus/std_driver/SYS/: sys_adpt.c
    ../anybus/std_driver/UTIL/: util.c
